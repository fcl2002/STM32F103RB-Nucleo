# Keil uVision project STM32F103RB-Nucleo.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: STM32F103R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103RB-Nucleo
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: io.h io.c delay.h delay.c serial.c serial.h i2c_bb.h i2c_bb.c pcf8574.h pcf8574.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
